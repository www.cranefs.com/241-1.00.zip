# Autodesk Inventor part: 241-1.0a0
## iProperties
Created: 2007-07
Part Number: 241-1.0a0
Document SubType Name: Modeling
Designer: btaylor
Density: 1 g/cm^3
Author: btaylor
